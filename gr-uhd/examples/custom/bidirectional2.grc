options:
  parameters:
    generate_options: qt_gui
    id: bidirectional2
    output_language: python
    title: 'RFNoC: Bidirectional2'
  states: {}

blocks:
- name: uhd_rfnoc_graph_0
  id: uhd_rfnoc_graph
  parameters:
    dev_addr: addr=10.10.23.2
  states: {}
- name: start_stream
  id: variable_qtgui_msg_push_button
  parameters:
    label: Start Stream
    msgName: pressed
    type: int
    value: '1'
  states: {}
- name: uhd_rfnoc_addcomplexmult_0
  id: uhd_rfnoc_addcomplexmult
  parameters:
    block_args: ''
    device_select: '-1'
    instance_index: '0'
    num_chans: '1'
  states: {}
- name: uhd_rfnoc_addcomplexmult_0_0
  id: uhd_rfnoc_addcomplexmult
  parameters:
    block_args: ''
    device_select: '-1'
    instance_index: '1'
    num_chans: '1'
  states: {}
- name: uhd_rfnoc_ddc_0
  id: uhd_rfnoc_ddc
  parameters:
    freq: '0'
    instance_index: '0'
    output_rate: 100e3
  states: {}
- name: uhd_rfnoc_ddc_0_0
  id: uhd_rfnoc_ddc
  parameters:
    freq: '0'
    instance_index: '1'
    output_rate: 100e3
  states: {}
- name: uhd_rfnoc_duc_0
  id: uhd_rfnoc_duc
  parameters:
    freq: '0'
    input_rate: 100e3
    instance_index: '1'
    propagation: 'False'
  states: {}
- name: uhd_rfnoc_duc_0_0
  id: uhd_rfnoc_duc
  parameters:
    freq: '0'
    input_rate: 100e3
    instance_index: '0'
    propagation: 'True'
  states: {}
- name: uhd_rfnoc_fir_0
  id: uhd_rfnoc_fir
  parameters:
    block_args: ''
    coeffs: '[32767, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0]'
    device_select: '-1'
    instance_index: '0'
    num_chans: '1'
  states: {}
- name: uhd_rfnoc_fir_0_0
  id: uhd_rfnoc_fir
  parameters:
    block_args: ''
    coeffs: '[32767, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0]'
    device_select: '-1'
    instance_index: '2'
    num_chans: '1'
  states: {}
- name: uhd_rfnoc_fir_1
  id: uhd_rfnoc_fir
  parameters:
    block_args: ''
    coeffs: '[32767, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0]'
    device_select: '-1'
    instance_index: '1'
    num_chans: '1'
  states: {}
- name: uhd_rfnoc_fir_1_0
  id: uhd_rfnoc_fir
  parameters:
    block_args: ''
    coeffs: '[32767, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0]'
    device_select: '-1'
    instance_index: '3'
    num_chans: '1'
  states: {}
- name: uhd_rfnoc_rx_radio_0_0
  id: uhd_rfnoc_rx_radio
  parameters:
    agc: Default
    antenna: RX2
    bandwidth: 200e6
    block_args: spp=128
    dc_offset: 'True'
    frequency: 1e9
    gain: '1'
    instance_index: '1'
    iq_balance: 'False'
    rate: 200e6
  states: {}
- name: uhd_rfnoc_rx_radio_0_0_0
  id: uhd_rfnoc_rx_radio
  parameters:
    agc: Default
    antenna: RX2
    bandwidth: 200e6
    block_args: spp=128
    dc_offset: 'True'
    frequency: 1e9
    gain: '1'
    instance_index: '0'
    iq_balance: 'False'
    rate: 200e6
  states: {}
- name: uhd_rfnoc_splitstream_0
  id: uhd_rfnoc_splitstream
  parameters:
    block_args: ''
    device_select: '-1'
    instance_index: '0'
    num_chans: '1'
  states: {}
- name: uhd_rfnoc_splitstream_0_0
  id: uhd_rfnoc_splitstream
  parameters:
    block_args: ''
    device_select: '-1'
    instance_index: '1'
    num_chans: '1'
  states: {}
- name: uhd_rfnoc_tx_radio_0
  id: uhd_rfnoc_tx_radio
  parameters:
    agc: Default
    antenna: TX/RX
    bandwidth: '0'
    block_args: spp=128
    frequency: 1e9
    gain: '1'
    instance_index: '1'
    rate: 200e6
  states: {}
- name: uhd_rfnoc_tx_radio_0_0
  id: uhd_rfnoc_tx_radio
  parameters:
    agc: Default
    antenna: TX/RX
    bandwidth: '0'
    block_args: spp=128
    frequency: 1e9
    gain: '1'
    instance_index: '0'
    rate: 200e6
  states: {}

connections:
- [start_stream, pressed, uhd_rfnoc_rx_radio_0_0, cmd]
- [start_stream, pressed, uhd_rfnoc_rx_radio_0_0_0, cmd]
- [uhd_rfnoc_addcomplexmult_0, '0', uhd_rfnoc_duc_0, '0']
- [uhd_rfnoc_addcomplexmult_0_0, '0', uhd_rfnoc_duc_0_0, '0']
- [uhd_rfnoc_ddc_0, '0', uhd_rfnoc_splitstream_0, '0']
- [uhd_rfnoc_ddc_0_0, '0', uhd_rfnoc_splitstream_0_0, '0']
- [uhd_rfnoc_duc_0, '0', uhd_rfnoc_tx_radio_0, '0']
- [uhd_rfnoc_duc_0_0, '0', uhd_rfnoc_tx_radio_0_0, '0']
- [uhd_rfnoc_fir_0, '0', uhd_rfnoc_addcomplexmult_0, '0']
- [uhd_rfnoc_fir_0_0, '0', uhd_rfnoc_addcomplexmult_0_0, '0']
- [uhd_rfnoc_fir_1, '0', uhd_rfnoc_addcomplexmult_0, '1']
- [uhd_rfnoc_fir_1_0, '0', uhd_rfnoc_addcomplexmult_0_0, '1']
- [uhd_rfnoc_rx_radio_0_0, '0', uhd_rfnoc_ddc_0_0, '0']
- [uhd_rfnoc_rx_radio_0_0_0, '0', uhd_rfnoc_ddc_0, '0']
- [uhd_rfnoc_splitstream_0, '0', uhd_rfnoc_fir_0, '0']
- [uhd_rfnoc_splitstream_0, '1', uhd_rfnoc_fir_1, '0']
- [uhd_rfnoc_splitstream_0_0, '0', uhd_rfnoc_fir_0_0, '0']
- [uhd_rfnoc_splitstream_0_0, '1', uhd_rfnoc_fir_1_0, '0']

metadata:
  file_format: 1
  grc_version: v3.9.5.0-62-gb64a46bf
