options:
  parameters:
    generate_options: qt_gui
    id: bidirectional2
    output_language: python
    title: 'RFNoC: Bidirectional2'
  states: {}

blocks:
- name: uhd_rfnoc_graph_0
  id: uhd_rfnoc_graph
  parameters:
    dev_addr: addr=10.10.23.2
  states: {}
- name: uhd_rfnoc_ddc_0
  id: uhd_rfnoc_ddc
  parameters:
    freq: '0'
    instance_index: '0'
    output_rate: 100e3
  states: {}
- name: uhd_rfnoc_duc_0
  id: uhd_rfnoc_duc
  parameters:
    freq: '0'
    input_rate: 400e3
    instance_index: '1'
  states: {}
- name: uhd_rfnoc_rx_radio_0
  id: uhd_rfnoc_rx_radio
  parameters:
    agc: Default
    antenna: RX2
    bandwidth: 200e6
    block_args: spp=128
    dc_offset: 'True'
    frequency: 1e9
    gain: '32'
    instance_index: '0'
    iq_balance: 'True'
    rate: 200e6
  states: {}
- name: uhd_rfnoc_tx_radio_0
  id: uhd_rfnoc_tx_radio
  parameters:
    agc: Default
    antenna: TX/RX
    bandwidth: '0'
    block_args: spp=128
    frequency: 1e9
    gain: '32'
    instance_index: '1'
    rate: 200e6
  states: {}

connections:
- [uhd_rfnoc_ddc_0, '0', uhd_rfnoc_duc_0, '0']
- [uhd_rfnoc_duc_0, '0', uhd_rfnoc_tx_radio_0, '0']
- [uhd_rfnoc_rx_radio_0, '0', uhd_rfnoc_ddc_0, '0']

metadata:
  file_format: 1
  grc_version: v3.9.6.0-2-gbf9b25e7
