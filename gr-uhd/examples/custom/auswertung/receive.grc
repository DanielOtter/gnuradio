options:
  parameters:
    generate_options: qt_gui
    id: receive
    output_language: python
    title: 'RFNoC: Receive'
  states: {}

blocks:
- name: uhd_rfnoc_graph_0
  id: uhd_rfnoc_graph
  parameters:
    dev_addr: addr=10.10.23.3
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 200e6
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: uhd_rfnoc_ddc_0
  id: uhd_rfnoc_ddc
  parameters:
    freq: '0'
    instance_index: '0'
    output_rate: 200e6
  states: {}
- name: uhd_rfnoc_rx_radio_0
  id: uhd_rfnoc_rx_radio
  parameters:
    agc: Disabled
    antenna: RX2
    bandwidth: 200e6
    block_args: spp=128
    dc_offset: 'False'
    frequency: 2.45e9
    gain: '30'
    instance_index: '0'
    iq_balance: 'False'
    rate: 200e6
  states: {}
- name: uhd_rfnoc_rx_streamer_0
  id: uhd_rfnoc_rx_streamer
  parameters:
    otw: sc16
    output_type: fc32
  states: {}

connections:
- [uhd_rfnoc_ddc_0, '0', uhd_rfnoc_rx_streamer_0, '0']
- [uhd_rfnoc_rx_radio_0, '0', uhd_rfnoc_ddc_0, '0']
- [uhd_rfnoc_rx_streamer_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: v3.9.6.0-5-g797c819d
