options:
  parameters:
    generate_options: qt_gui
    id: send
    output_language: python
    title: 'RFNoC: Send'
  states: {}

blocks:
- name: uhd_rfnoc_graph_0
  id: uhd_rfnoc_graph
  parameters:
    dev_addr: addr=10.10.23.2
  states: {}
- name: variable_qtgui_entry_0
  id: variable_qtgui_entry
  parameters:
    type: real
    value: 2.45e9
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: complex
  states: {}
- name: uhd_rfnoc_duc_0
  id: uhd_rfnoc_duc
  parameters:
    freq: '0'
    input_rate: 20e6
    instance_index: '0'
    propagation: 'False'
  states: {}
- name: uhd_rfnoc_tx_radio_0
  id: uhd_rfnoc_tx_radio
  parameters:
    agc: Default
    antenna: TX/RX
    bandwidth: 200e6
    block_args: '"spp:0=128"'
    frequency: variable_qtgui_entry_0
    gain: '30'
    instance_index: '0'
    rate: 200e6
  states: {}
- name: uhd_rfnoc_tx_streamer_0
  id: uhd_rfnoc_tx_streamer
  parameters:
    input_type: fc32
    otw: sc16
  states: {}

connections:
- [analog_const_source_x_0, '0', uhd_rfnoc_tx_streamer_0, '0']
- [uhd_rfnoc_duc_0, '0', uhd_rfnoc_tx_radio_0, '0']
- [uhd_rfnoc_tx_streamer_0, '0', uhd_rfnoc_duc_0, '0']

metadata:
  file_format: 1
  grc_version: v3.9.6.0-5-g797c819d
