options:
  parameters:
    generate_options: qt_gui
    id: receive
    output_language: python
    title: 'RFNoC: Receive'
  states: {}

blocks:
- name: uhd_rfnoc_graph_0
  id: uhd_rfnoc_graph
  parameters:
    dev_addr: addr=10.10.23.3
  states: {}
- name: variable_qtgui_entry_0
  id: variable_qtgui_entry
  parameters:
    type: real
    value: 2.45e9
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: complex
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: complex
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 200e6
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: uhd_rfnoc_addcomplexmult_0
  id: uhd_rfnoc_addcomplexmult
  parameters:
    block_args: ''
    device_select: '-1'
    instance_index: '0'
    num_chans: '1'
  states: {state: disabled}
- name: uhd_rfnoc_ddc_0
  id: uhd_rfnoc_ddc
  parameters:
    freq: '0'
    instance_index: '0'
    output_rate: 200e6
  states: {}
- name: uhd_rfnoc_duc_0
  id: uhd_rfnoc_duc
  parameters:
    freq: '0'
    input_rate: 20e6
    instance_index: '0'
    propagation: 'False'
  states: {}
- name: uhd_rfnoc_duc_0_0
  id: uhd_rfnoc_duc
  parameters:
    freq: '0'
    input_rate: 20e6
    instance_index: '0'
    propagation: 'False'
  states: {state: disabled}
- name: uhd_rfnoc_fir_0
  id: uhd_rfnoc_fir
  parameters:
    block_args: ''
    coeffs: '[32767//4, 0, 0, 0, 32767//4, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0]'
    device_select: '-1'
    instance_index: '0'
    num_chans: '1'
  states: {state: disabled}
- name: uhd_rfnoc_fir_1
  id: uhd_rfnoc_fir
  parameters:
    block_args: ''
    coeffs: '[0, 32767//4, 0, 0, 0, 0, 32767//4, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0]'
    device_select: '-1'
    instance_index: '1'
    num_chans: '1'
  states: {state: disabled}
- name: uhd_rfnoc_rx_radio_0
  id: uhd_rfnoc_rx_radio
  parameters:
    agc: Disabled
    antenna: RX2
    bandwidth: 200e6
    block_args: spp=128
    dc_offset: 'False'
    frequency: 2.45e9
    gain: '30'
    instance_index: '0'
    iq_balance: 'False'
    rate: 200e6
  states: {}
- name: uhd_rfnoc_rx_streamer_0
  id: uhd_rfnoc_rx_streamer
  parameters:
    otw: sc16
    output_type: fc32
  states: {}
- name: uhd_rfnoc_splitstream_0
  id: uhd_rfnoc_splitstream
  parameters:
    block_args: ''
    device_select: '-1'
    instance_index: '0'
    num_chans: '1'
  states: {state: disabled}
- name: uhd_rfnoc_tx_radio_0
  id: uhd_rfnoc_tx_radio
  parameters:
    agc: Default
    antenna: TX/RX
    bandwidth: 200e6
    block_args: '"spp:0=128"'
    frequency: variable_qtgui_entry_0
    gain: '30'
    instance_index: '0'
    rate: 200e6
  states: {}
- name: uhd_rfnoc_tx_radio_0_0
  id: uhd_rfnoc_tx_radio
  parameters:
    agc: Default
    antenna: TX/RX
    bandwidth: 200e6
    block_args: '"spp:0=128"'
    frequency: variable_qtgui_entry_0
    gain: '30'
    instance_index: '0'
    rate: 200e6
  states: {state: disabled}
- name: uhd_rfnoc_tx_streamer_0
  id: uhd_rfnoc_tx_streamer
  parameters:
    input_type: fc32
    otw: sc16
  states: {}
- name: uhd_rfnoc_tx_streamer_0_0
  id: uhd_rfnoc_tx_streamer
  parameters:
    input_type: fc32
    otw: sc16
  states: {state: disabled}

connections:
- [analog_const_source_x_0, '0', uhd_rfnoc_tx_streamer_0, '0']
- [analog_const_source_x_0_0, '0', uhd_rfnoc_tx_streamer_0_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [uhd_rfnoc_addcomplexmult_0, '0', uhd_rfnoc_duc_0_0, '0']
- [uhd_rfnoc_ddc_0, '0', uhd_rfnoc_rx_streamer_0, '0']
- [uhd_rfnoc_duc_0, '0', uhd_rfnoc_tx_radio_0, '0']
- [uhd_rfnoc_duc_0_0, '0', uhd_rfnoc_tx_radio_0_0, '0']
- [uhd_rfnoc_fir_0, '0', uhd_rfnoc_addcomplexmult_0, '0']
- [uhd_rfnoc_fir_1, '0', uhd_rfnoc_addcomplexmult_0, '1']
- [uhd_rfnoc_rx_radio_0, '0', uhd_rfnoc_ddc_0, '0']
- [uhd_rfnoc_rx_streamer_0, '0', blocks_probe_rate_0, '0']
- [uhd_rfnoc_rx_streamer_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_rfnoc_splitstream_0, '0', uhd_rfnoc_fir_0, '0']
- [uhd_rfnoc_splitstream_0, '1', uhd_rfnoc_fir_1, '0']
- [uhd_rfnoc_tx_streamer_0, '0', uhd_rfnoc_duc_0, '0']
- [uhd_rfnoc_tx_streamer_0_0, '0', uhd_rfnoc_splitstream_0, '0']

metadata:
  file_format: 1
  grc_version: v3.9.6.0-5-g797c819d
